# Keil uVision project 超声波测距.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 超声波测距 +hex
  c flags: Optimize=8 SizeSpeed=1
  group source files
    ../files/: main.c hcsr04.c led.c iic.c key.c dac.c smg.c app.c
  group include files
    ../files/: main.h hcsr04.h config.h iic.h led.h key.h dac.h smg.h app.h
